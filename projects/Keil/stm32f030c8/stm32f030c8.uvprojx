# Keil uVision project stm32f030c8.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f030c8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L073RZTx\" -DSYSINFO_DEVICE_NAME=\"STM32L073RZTx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.4\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\include;..\..\..\kernel\rhino\include;..\..\..\platform\arch\arm\armv6m\armcc\m0;..\..\..\platform\mcu\stm32f0xx\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\platform\mcu\stm32f0xx\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;..\..\..\platform\mcu\stm32f0xx\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\platform\mcu\stm32f0xx\Drivers\CMSIS\Include;..\..\..\platform\mcu\stm32f0xx\src\stm32f030c8;..\..\..\include\hal;..\..\..\kernel\vcall\aos;..\..\..\utility\libc\compilers\armlibc;..\..\..\platform\mcu\stm32f0xx\drivers\STM32F0xx_HAL_Driver;..\..\..\platform\mcu\stm32f0xx\drivers\STM32F0xx_HAL_Driver\Src;..\..\..\platform\arch\arm\armv6m\common;..\..\..\kernel\rhino\core\include;..\..\..\utility\cjson\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group platform\mcu\stm32f0xx\aos
    ../../../platform/mcu/stm32f0xx/aos/: soc_impl.c
  group platform\mcu\stm32f0xx\Drivers\STM32F0xx_HAL_Driver\Src
    ../../../platform/mcu/stm32f0xx/drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group platform\mcu\stm32f0xx\src\stm32f030c8
    ../../../platform/mcu/stm32f0xx/src/stm32f030c8/: soc_init.c stm32f0xx_hal_msp.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030x8_keil.s
  group kernel\rhino\core
    ../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group utility\libc\compilers\armlibc
    ../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group platform\arch\arm\armv6m\armcc\m0
    ../../../platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group app
    ../../../example/appexample/: appexample.c
